<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8S_74HC595_LCD16x2.ewp</path>
    </project>
    <batchBuild />
</workspace>
