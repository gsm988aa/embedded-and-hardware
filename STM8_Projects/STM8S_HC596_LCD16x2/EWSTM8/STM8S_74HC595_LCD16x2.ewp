# IAR project STM8S_74HC595_LCD16x2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S005; RTC_USE_DS1307; USE_74HC595_DRIVER
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\Drivers\inc; ..\Source; ..\Librarys
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_74HC595_LCD16x2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    ../Drivers/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c
  group Librarys
    ../Librarys/: DELAY.c DS1307.c DS18B20.c I2C.c LCD16X2.c
  group Source
    ../Source/: main.c stm8s_it.c
