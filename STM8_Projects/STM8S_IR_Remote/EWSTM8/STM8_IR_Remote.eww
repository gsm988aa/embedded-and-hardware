<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8_IR_Remote.ewp</path>
    </project>
    <batchBuild />
</workspace>
