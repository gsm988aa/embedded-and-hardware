<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8S_Matrix_Clock_V2_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
