# IAR project STM8S_Matrix_Clock_V2_0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\Drivers\inc; ..\Librarys; ..\Source
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_Matrix_Clock_V2_0.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    ../Drivers/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_itc.c stm8s_tim4.c
  group Librarys
    ../Librarys/: DELAY.c DS1307.c I2C.c matrix_drv.c
  group Source
    ../Source/: main.c stm8s_it.c
