<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8S_LCD_16X2.ewp</path>
    </project>
    <batchBuild />
</workspace>
