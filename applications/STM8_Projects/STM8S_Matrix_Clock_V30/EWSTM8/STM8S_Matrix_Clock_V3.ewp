# IAR project STM8S_Matrix_Clock_V3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\Drivers\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_Matrix_Clock_V3.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    ../Drivers/src/: i2c_driver.c matrix_driver.c rtc_driver.c
  group Source
    ../Source/: main.c
